# Keil uVision project ROTATING DRUM COLLECTOR.uvprojx, settings and files
target ROTATING DRUM COLLECTOR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ROTATING DRUM COLLECTOR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\Project;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport\ST\STM32F10x\startup\arm;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Source\inc;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group User
    ../Source/: main.c stm32f10x_it.c system_stm32f10x.c
  group CMSIS
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
  group StdPeriphDriver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_flash.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group Startup
    ../Libraries/CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group Source
    ../Source/src/: sermotor_config.c pid.c button_config.c enc_config.c LiquidCrystal_I2C.c at24cxx.c usart.c delay.c i2c.c
    ./: Readme.txt
